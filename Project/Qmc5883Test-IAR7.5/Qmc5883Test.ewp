# IAR project Qmc5883Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xB ST STM32L151xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L151xB
  ICCARM.CCIncludePath2: ../../Apps/Config; ../../Drivers\Inc; ../../Drivers\Core\CMSIS\Device; ../../Drivers\Core\CMSIS\CortexM3\Inc; ../../Drivers\Core\CMSIS\RTOS\Template; ../../Drivers/Core/CMSIS/Device/ST/STM32L1xx/Include; ../../Drivers/Core/STM32L1xx_HAL_Driver/Config; ../../Drivers/Core/STM32L1xx_HAL_Driver/Inc; ../../Drivers/Core/STM32L1xx_HAL_Driver/Inc/Legacy; ../../Middlewares/Lib; ../../Middlewares/Lib/Inc; ../../Middlewares/FreeRTOS/Source/portable/IAR/ARM_CM3; ../../Middlewares/FreeRTOS/Source/include; ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../../Middlewares/SeggerSystemView/Segger; ../../Middlewares/SeggerSystemView/Config; ../../Drivers/Core/CMSIS/Include; ../../Drivers/Core/RTT; ../../Drivers; ../../BSP/Inc/; ../../Drivers/Core/CMSIS/Device/ST/STM32L1xx/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Apps\Config
  OBJCOPY.OOCOutputFile: Qmc5883Test.srec
  prebuild: Script\clear_cpu_obj.bat Debug\Obj\
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ../../Link/stm32l151xb_flash.icf
  ILINK.IlinkExtraOptions: --log sections; --log initialization
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Apps
    ../../Apps/Qmc5883Test/: main.c
  group Apps/Config
    ../../Apps/Config/: Config.h
  group Bsp/Inc
    ../../Bsp/Inc/: bsp.h bsp_com.h bsp_hmc5983.h bsp_lowpower.h bsp_m24lr04e.h bsp_qmc5883l.h
  group Bsp/Src
    ../../Bsp/Src/: bsp.c bsp_com.c bsp_hmc5983.c bsp_lowpower.c bsp_m24lr04e.c bsp_qmc5883l.c
  group Drivers/Core/CMSIS/CortecM3/Inc
    ../../Drivers/Core/CMSIS/CortexM3/Inc/: core_cm3.h interrupt.h
  group Drivers/Core/CMSIS/CortecM3/Src
    ../../Drivers/Core/CMSIS/CortexM3/Src/: interrupt.c startup_cm3.s
  group Drivers/Core/CMSIS/Device
    ../../Drivers/Core/CMSIS/Device/: stm32l151xb.h stm32l151xd.h
  group Drivers/Core/STM32L1xx_HAL_Driver/Config
    ../../Drivers/Core/STM32L1xx_HAL_Driver/Config/: stm32l1xx_hal_conf.h stm32l1xx_hal_msp.c system_stm32l1xx.c system_stm32l1xx.h
  group Drivers/Core/STM32L1xx_HAL_Driver/Inc
    ../../Drivers/Core/STM32L1xx_HAL_Driver/Inc/: stm32_assert_template.h stm32l1xx_hal.h stm32l1xx_hal_adc.h stm32l1xx_hal_adc_ex.h stm32l1xx_hal_comp.h stm32l1xx_hal_comp_ex.h stm32l1xx_hal_conf_template.h stm32l1xx_hal_cortex.h stm32l1xx_hal_crc.h stm32l1xx_hal_cryp.h stm32l1xx_hal_cryp_ex.h stm32l1xx_hal_dac.h stm32l1xx_hal_dac_ex.h stm32l1xx_hal_def.h stm32l1xx_hal_dma.h stm32l1xx_hal_flash.h stm32l1xx_hal_flash_ex.h stm32l1xx_hal_flash_ramfunc.h stm32l1xx_hal_gpio.h stm32l1xx_hal_gpio_ex.h stm32l1xx_hal_i2c.h stm32l1xx_hal_i2s.h stm32l1xx_hal_irda.h stm32l1xx_hal_iwdg.h stm32l1xx_hal_lcd.h stm32l1xx_hal_nor.h stm32l1xx_hal_opamp.h stm32l1xx_hal_opamp_ex.h stm32l1xx_hal_pcd.h stm32l1xx_hal_pcd_ex.h stm32l1xx_hal_pwr.h stm32l1xx_hal_pwr_ex.h stm32l1xx_hal_rcc.h stm32l1xx_hal_rcc_ex.h stm32l1xx_hal_rtc.h stm32l1xx_hal_rtc_ex.h stm32l1xx_hal_sd.h stm32l1xx_hal_smartcard.h stm32l1xx_hal_spi.h stm32l1xx_hal_spi_ex.h stm32l1xx_hal_sram.h stm32l1xx_hal_tim.h stm32l1xx_hal_tim_ex.h stm32l1xx_hal_uart.h stm32l1xx_hal_usart.h stm32l1xx_hal_wwdg.h stm32l1xx_ll_adc.h stm32l1xx_ll_bus.h stm32l1xx_ll_comp.h stm32l1xx_ll_cortex.h stm32l1xx_ll_crc.h stm32l1xx_ll_dac.h stm32l1xx_ll_dma.h stm32l1xx_ll_exti.h stm32l1xx_ll_fsmc.h stm32l1xx_ll_gpio.h stm32l1xx_ll_i2c.h stm32l1xx_ll_iwdg.h stm32l1xx_ll_opamp.h stm32l1xx_ll_pwr.h stm32l1xx_ll_rcc.h stm32l1xx_ll_rtc.h stm32l1xx_ll_sdmmc.h stm32l1xx_ll_spi.h stm32l1xx_ll_system.h stm32l1xx_ll_tim.h stm32l1xx_ll_usart.h stm32l1xx_ll_utils.h stm32l1xx_ll_wwdg.h
  group Drivers/Core/STM32L1xx_HAL_Driver/Src
    ../../Drivers/Core/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_adc.c stm32l1xx_ll_comp.c stm32l1xx_ll_crc.c stm32l1xx_ll_dac.c stm32l1xx_ll_dma.c stm32l1xx_ll_exti.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_gpio.c stm32l1xx_ll_i2c.c stm32l1xx_ll_opamp.c stm32l1xx_ll_pwr.c stm32l1xx_ll_rcc.c stm32l1xx_ll_rtc.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_spi.c stm32l1xx_ll_tim.c stm32l1xx_ll_usart.c stm32l1xx_ll_utils.c
  group Drivers/Inc
    ../../Drivers/Inc/: dev_clock.h dev_flash.h dev_gpio.h dev_i2c.h dev_sleep.h dev_spi.h dev_uart.h dev_watchdog.h device.h
  group Drivers/Src
    ../../Drivers/Src/: dev_clock.c dev_flash.c dev_gpio.c dev_i2c.c dev_sleep.c dev_spi.c dev_uart.c dev_watchdog.c device.c
  group Link
    ../../Link/: stm32l151xd_flash.icf
  group Middlewares/Lib/Inc
    ../../Middlewares/Lib/Inc/: cpu.h debug.h fifo.h lib.h printf.h queue.h util.h
  group Middlewares/Lib/Src
    ../../Middlewares/Lib/Src/: cpu.c debug.c fifo.c printf.c queue.c util.c
  group Middlewares/SeggerSystemView/Config
    ../../Middlewares/SeggerSystemView/Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_Config_NoOS.c
  group Middlewares/SeggerSystemView/Segger
    ../../Middlewares/SeggerSystemView/Segger/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
